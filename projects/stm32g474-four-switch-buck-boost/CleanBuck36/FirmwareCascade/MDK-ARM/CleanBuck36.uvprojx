# Keil uVision project CleanBuck36.uvprojx, settings and files
target CLEANBUCK36_BENCH (ARM-ADS)
  device: STM32G474RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CLEANBUCK36_BENCH +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../../Simulation/CurrentCascade;../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Open-loop application
    ../Core/Src/: main.c board.c
    ../../Simulation/CurrentCascade/: cascade_control.c
  group ST startup and system
    ./: startup_stm32g474xx.s
    ../Core/Src/: system_stm32g4xx.c
  group ST HAL
    ../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_hrtim.c
